RDEPENDS:${PN} += "nativesdk-python3-cheetah"
